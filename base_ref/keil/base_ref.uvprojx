# Keil uVision project base_ref.uvprojx, settings and files
target base_ref (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: base_ref +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __FILE_INCOMPLETE=1,USE_STDPERIPH_DRIVER,STM32F10X_HD,USART_ENABLE_USART3,CONFIG_BREAKOUT_REV=3,USE_FRONT_IR_SENSORS,_DEBUG
  c include: ..\src\common;..\src\drv;..\src;..\src\utils;..\..\infra_pub\arch\infra_stm32;..\..\infra_pub\arch\infra_stm32\32f10x;..\..\infra_pub\arch\infra_stm32\net;..\..\infra_pub\net;..\..\infra_pub\arch\st_fwlib\CMSIS\CM3\CoreSupport;..\..\infra_pub\arch\st_fwlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\infra_pub\arch\st_fwlib\STM32F10x_StdPeriph_Driver\inc;..\..\infra_pub\hal;..\..\infra_pub
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group BoardFuncs
    ../src/utils/: filters.h filters.c util.c
    ../src/boardfunc/: stm32f10x_it.c stm32f10x_it.h
  group common
    ../src/common/: common.h
  group drv
    ../src/drv/: battery.c battery.h beep.c beep.h bump.c bump.h ctrl_bus_cmd.h distir.c distir.h drv_ctrlbus.c drv_ctrlbus.h gpio.c gpio.h homeir.c homeir.h irdecoder.c irdecoder.h led.c led.h motor.c motor.h serial_channel.c serial_channel.h sonar.c sonar.h watchdog.c watchdog.h health_monitor.c health_monitor.h
  group FWLib
    ../../infra_pub/arch/st_fwlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../infra_pub/arch/st_fwlib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Runtime
    ../../infra_pub/arch/infra_stm32/net/: interchip.c interchip.h
    ../../infra_pub/arch/infra_stm32/: rpstm32.h
    ../../infra_pub/arch/infra_stm32/32f10x/: boarddrv.c boardfunc.h softdelay.c softdelay.h usart.c usart.h
  group Source
    ../src/: binary_config.c boarddef.h bump_monitor.c bump_monitor.h hwconf.c main.c request_handler.c stm32f10x_conf.h
  group CMSIS
    ../../infra_pub/arch/st_fwlib/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../../infra_pub/arch/st_fwlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../../infra_pub/arch/st_fwlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c system_stm32f10x.h
software components: CMSIS:CORE 5.0.0
